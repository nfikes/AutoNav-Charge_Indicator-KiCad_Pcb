File: Wireless E-Stop/Wireless E-Stop.kicad_sch (KiCad schematic)
At the start: 1 part

Commit message: Updated things.
Other:
- note removed: "SSR"
